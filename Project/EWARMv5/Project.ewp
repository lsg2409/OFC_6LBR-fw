# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; CETIC_6LBR_ROUTER; WEBSERVER; UIP_CONF_IPV6
  ICCARM.CCDiagSuppress: pa050
  ICCARM.CCIncludePath2: ..\..\Utilities\contiki\apps\6lbr; ..\..\Utilities\contiki\core\; ..\..\Utilities\contiki\core\dev\; ..\..\Utilities\contiki\core\lib\; ..\..\Utilities\contiki\core\net\; ..\..\Utilities\contiki\core\net\ip; ..\..\Utilities\contiki\core\net\ipv4; ..\..\Utilities\contiki\core\net\ipv6; ..\..\Utilities\contiki\core\net\mac; ..\..\Utilities\contiki\core\net\rime; ..\..\Utilities\contiki\core\net\rpl; ..\..\Utilities\contiki\core\sys\; ..\..\Libraries\CMSIS\Core\CM3; ..\..\Libraries\STM32_ETH_Driver\inc; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Utilities\uCEVAL_STM32F107; ..\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: E:\Project\WsCom\MicrumSTM32\6lbrSTM32-实现IPv6通信\Project\EWARMv5\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group apps/6lbr
    ../../Utilities/contiki/apps/6lbr/: cetic-6lbr.c ip64-addr.c ip64-addrmap.c ip64-arp.c ip64.c nvm-config.c packet-filter.c rio.c sicslow-ethernet.c
  group apps/6lbr/node-info
    ../../Utilities/contiki/apps/6lbr/: node-info.c node-info.h
  group apps/6lbr/webserver
    ../../Utilities/contiki/apps/6lbr/: httpd-simple.c httpd-simple.h webserver.c
  group CMSIS
    ../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group contiki/dev
    ../../Utilities/contiki/core/dev/: nullradio.c
  group contiki/lib
    ../../Utilities/contiki/core/lib/: assert.c checkpoint.c crc16.c ifft.c list.c memb.c mmem.c print-stats.c random.c ringbuf.c
  group contiki/net
    ../../Utilities/contiki/core/net/: linkaddr.c nbr-table.c netstack.c packetbuf.c queuebuf.c
  group contiki/net/ip
    ../../Utilities/contiki/core/net/ip/: psock.c tcpip.c uip-debug.c uip-udp-packet.c uiplib.c
  group contiki/net/ipv6
    ../../Utilities/contiki/core/net/ipv6/: sicslowpan.c sicslowpan.h uip-ds6-nbr.c uip-ds6-nbr.h uip-ds6-route.c uip-ds6-route.h uip-ds6.c uip-ds6.h uip-icmp6.c uip-icmp6.h uip-nd6.c uip-nd6.h uip6.c
  group contiki/net/mac
    ../../Utilities/contiki/core/net/mac/: csma.c frame802154.c framer-802154.c framer-nullmac.c mac-sequence.c mac.c nullrdc.c
  group contiki/net/rime
    ../../Utilities/contiki/core/net/rime/: rimestats.c
  group contiki/net/rpl
    ../../Utilities/contiki/core/net/rpl/: rpl-conf.h rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-private.h rpl-timers.c rpl.c rpl.h
  group contiki/sys
    ../../Utilities/contiki/core/sys/: arg.c autostart.c ctimer.c energest.c etimer.c process.c procinit.c rtimer.c stimer.c timer.c
  group ETHLib
    ../../Libraries/STM32_ETH_Driver/src/: stm32_eth.c
  group EWARMv5
    ../../Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_cl.s
  group FWLib
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group uCEVAL_STM32F107
    ../../Utilities/uCEVAL_STM32F107/: bsp.c
  group User
    ../src/: at86rf231.c clock.c ipv64-server.c main.c phy-arch.c rtimer-arch.c stm32-nvm.c stm32_eth-driver.c stm32f107.c stm32f10x_it.c watchdog.c
    ../inc/: contiki-conf.h project-conf.h
